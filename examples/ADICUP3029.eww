<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AD5940_ADC\ADICUP3029\AD5940_ADC.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_Amperometric\ADICUP3029\AD5940_Amperometric.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_BATImpedance\ADICUP3029\AD5940_BATImpedance.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_BIA\ADICUP3029\AD5940_BIA.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_BioElec\ADICUP3029\AD5940_BioElec.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_BIOZ-2Wire\ADICUP3029\AD5940_BIOZ-2Wire.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_ChronoAmperometric\ADICUP3029\AD5940_ChronoAmperometric.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_DFT\ADICUP3029\AD5940_DFT.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_ECG\ADICUP3029\AD5940_ECG.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_ECSns_EIS\ADICUP3029\AD5940_ECSensEIS.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_EDA\ADICUP3029\AD5940_EDA.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_HSDACCal\ADICUP3029\AD5940_HSDACCal.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_Impedance\ADICUP3029\AD5940_Impedance.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_LPDAC\ADICUP3029\AD5940_LPDAC.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_LPLoop\ADICUP3029\AD5940_LPLoop.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_Ramp\ADICUP3029\AD5940_Ramp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_Reset\ADICUP3029\AD5940_Reset.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_Sequencer\ADICUP3029\AD5940_Sequencer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_SPI\ADICUP3029\AD5940_SPI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_SqrWaveVoltammetry\ADICUP3029\AD5940_SqrWaveVoltmmetry.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_Temperature\ADICUP3029\AD5940_Temperature.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\AD5940_WG\ADICUP3029\AD5940_WG.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Debug</name>
            <member>
                <project>AD5940_ADC</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
